# Keil uVision project CS99XX.uvproj, settings and files
target 不支持bootloader (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZWP_M_V2_20_74 +hex
  BeforeMake: .\1.bat
  AfterMake: xcopy.exe ..\cs99xx_zwp_output\obj\*.hex ..\ /Y
  AfterMake: .\del_hex.bat
  c flags: Optim=1
  c include: ..\source\Libraries\CMSIS;..\source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\source\USER;..\source\APP;..\source\APP\CS99XX;..\source\APP\AutoCal;..\source\BSP\45PE16;..\source\BSP\ADC;..\source\BSP\ADC_DMA;..\source\BSP\BSP_Config;..\source\BSP\DAC;..\source\BSP\EE_I2C;..\source\BSP\FSMC_Config;..\source\BSP\GPIO_Config;..\source\BSP\IIC_Config;..\source\BSP\KeyBoard;..\source\BSP\m45pe16_spi_flash;..\source\BSP\MC14094;..\source\BSP\RTC_Config;..\source\BSP\SineWave;..\source\BSP\SPI_CPLD;..\source\BSP\Timer5;..\source\BSP\Timer_Config;..\source\CMSIS;..\source\Comm_app;..\source\FreeModbus\modbus\include;..\source\FreeModbus\modbus;..\source\FreeModbus\port;..\source\uCGUI;..\source\uCGUI\GUI_LIB\Heads;..\source\uCGUI\GUI_LIB;..\source\uCOSII\core;..\source\uCOSII\port;..\source\uCGUI\GUI_LIB\EnglishFont;..\source\uCGUI\GUI_LIB\Picture;..\source\FreeModbus\modbus\rtu;..\source\module\DC_GR_MODULE;..\source\module;..\source\BSP\SPI_FLASH;..\Project
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32F10x_CMSIS
    ../source/Libraries/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group STM32FWLIB
    ../source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../source/USER/: app_cfg.h main.c os_cfg.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group TYPE_Config
    ../source/APP/CS99XX/: cs99xx_type.c cs99xx_type_config.h cs99xx_config.h
    ./: cs99xx_update.h
  group APP
    ../source/APP/: app.c
    ../source/APP/CS99XX/: calibration.c cs99xx.c cs99xx_buzzer.c cs99xx_collect.c cs99xx_com.c cs99xx_eep_manage.c cs99xx_err_log.c cs99xx_exception.c cs99xx_flash_manage.c cs99xx_interface.c cs99xx_ir_shift_gear.c cs99xx_it.c cs99xx_led.c cs99xx_list.c cs99xx_lock_key.c cs99xx_mem_api.c cs99xx_memory.c cs99xx_offset.c cs99xx_par_acw.c cs99xx_par_com.c cs99xx_par_dcw.c cs99xx_par_gr.c cs99xx_par_ir.c cs99xx_parameter.c cs99xx_plc.c cs99xx_pw.c cs99xx_relay_motion.c cs99xx_result.c cs99xx_set_par_path.c cs99xx_struct.c cs99xx_sys.c cs99xx_time.c cs99xx_vref.c general_test.c irq.c on_chip_flash_api.c serve_test.c cs99xx_custom.c cs99xx_bbd.c
    ../source/APP/MD5/: MD5.C
  group ACW
    ../source/APP/ACW/: acw_relay.c acw_test.c acw_count.c
  group Auto_cal
    ../source/APP/AutoCal/: auto_cal_comm.c auto_cal_crc.c auto_cal_server.c auto_calibration.c
  group BSP
    ../source/BSP/BSP_Config/: BSP_config.c
    ../source/BSP/FSMC_Config/: STM32_FSMC.C
    ../source/BSP/RTC_Config/: RTC_Config.c
    ../source/BSP/Timer_Config/: Timer_Config.c
    ../source/BSP/GPIO_Config/: STM32_GPIO_Config.c
    ../source/BSP/KeyBoard/: keyboard.c
    ../source/BSP/EE_I2C/: i2c_ee.c
    ../source/BSP/MC14094/: MC14094.C
    ../source/BSP/DAC/: DAC_VREF.c
    ../source/BSP/ADC/: STM32_ADC.c
    ../source/BSP/SPI_CPLD/: SPI_CPLD.C
    ../source/BSP/ADC_DMA/: ADC_DMA.c
    ../source/BSP/Timer5/: Timer5_Config.c
    ../source/BSP/SPI_FLASH/: spi_flash.c
    ../source/BSP/USART_Config/: uart.c
  group uCOS_Core
    ../source/uCOSII/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS_Port
    ../source/uCOSII/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group GUI_99XX_ZW
    ../source/APP/: GUI_Draw.c
  group GUI-LIB
    ../source/uCGUI/GUI_LIB/: LCD24064.H LCD24064.lib
  group GUI-Fonts
    ../source/uCGUI/GUI_LIB/EnglishFont/: Font_DIY.h Garamond_16.c
    ../source/uCGUI/GUI_LIB/ChineseFont/: SimSun_12.c SimSun_13.c SimSun_15.c SimSun_16.c fangzhengxingkai_24.c MS_Sans_Serif_24.c SimSunF_15.c
  group GUI-Pictrues
    ../source/uCGUI/GUI_LIB/Picture/: 16bit.c allwin.c arrow.c arrow_right.c back.c circle.c circle_.c colon.c del.c down.c index.c leftshift.c logo.c picture.c rightshift.c shortcut.c up.c warning.c
  group Comm_app
    ../source/Comm_app/: cs99xx_for_comm.c cs99xx_for_comm.h mb_cmd_define.h mb_interface.c mb_master.c mb_master.h mb_server.c mb_server.h
  group FreeMb_S
    ../source/FreeModbus/modbus/: mb.c
    ../source/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../source/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../source/FreeModbus/port/: port.c portevent.c portserial.c porttimer.c user_mb_app.c
  group FreeMb_M
    ../source/FreeModbus/modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncfile_m.c mbfuncholding_m.c mbfuncinput_m.c
    ../source/FreeModbus/modbus/rtu/: mbrtu_m.c
    ../source/FreeModbus/modbus/: mb_m.c
    ../source/FreeModbus/port/: portevent_m.c portserial_m.c porttimer_m.c
  group DC_GR_MODULE
    ../source/module/DC_GR_MODULE/: dc_module.c dc_module_bridge.c mb_dc_module.c
  group MODULE
    ../source/module/: module.c
  group Document
    ../source/Document/: 主要函数的说明.txt Ωμ.txt 说明.txt 9929宋体小五.txt 9929宋体四号.txt 9929宋体11.txt 99XX宋体10.txt 99xx方正行楷小二.txt ASCII码对照表.txt cs99xx宋体小四.txt
target 支持bootloader (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: 99_ZWP_M +hex
  BeforeMake: .\1.bat
  AfterMake: fromelf.exe --bin -o ../99_ZWP_M.bin  ../cs99xx_zwp_output/obj/99_ZWP_M.axf
  AfterMake: .\del_hex.bat
  c flags: Optim=1
  c define: BOOT_LOADER,
  c include: ..\source\Libraries\CMSIS;..\source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\source\USER;..\source\APP;..\source\APP\CS99XX;..\source\APP\AutoCal;..\source\BSP\SPI_FLASH;..\source\BSP\ADC;..\source\BSP\ADC_DMA;..\source\BSP\BSP_Config;..\source\BSP\DAC;..\source\BSP\EE_I2C;..\source\BSP\FSMC_Config;..\source\BSP\GPIO_Config;..\source\BSP\IIC_Config;..\source\BSP\KeyBoard;..\source\BSP\m45pe16_spi_flash;..\source\BSP\MC14094;..\source\BSP\RTC_Config;..\source\BSP\SineWave;..\source\BSP\SPI_CPLD;..\source\BSP\Timer5;..\source\BSP\Timer_Config;..\source\CMSIS;..\source\Comm_app;..\source\FreeModbus\modbus\include;..\source\FreeModbus\modbus;..\source\FreeModbus\port;..\source\uCGUI;..\source\uCGUI\GUI_LIB\Heads;..\source\uCGUI\GUI_LIB;..\source\uCOSII\core;..\source\uCOSII\port;..\source\uCGUI\GUI_LIB\EnglishFont;..\source\uCGUI\GUI_LIB\Picture;..\source\FreeModbus\modbus\rtu;..\source\module\DC_GR_MODULE;..\source\module;..\Project;..\source\BSP\USART_Config;..\source\APP\ACW
  memory RVCT4: ROM 0x800f000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
